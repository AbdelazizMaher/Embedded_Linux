addtask build
addtask clean